# Keil uVision project TB6612FNG.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TB6612FNG +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\hardware;.\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ./user/: MAIN.C
  group HARDWARE
    ./hardware/: GPIO.C TIMER.C dianji.c motor.h dianji.h timer.h
  group FWLIB
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.0.1
